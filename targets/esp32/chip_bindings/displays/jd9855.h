/*
Copyright (c) 2020 lovyan03 (https://github.com/lovyan03)

All rights reserved.

Redistribution and use in source and binary forms, with or without
modification, are permitted provided that the following conditions are met:

1. Redistributions of source code must retain the above copyright notice, this
   list of conditions and the following disclaimer.
2. Redistributions in binary form must reproduce the above copyright notice,
   this list of conditions and the following disclaimer in the documentation
   and/or other materials provided with the distribution.

THIS SOFTWARE IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS "AS IS" AND
ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED
WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE
DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT OWNER OR CONTRIBUTORS BE LIABLE FOR
ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES
(INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES;
LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND
ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT
(INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE OF THIS
SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.

The views and conclusions contained in the software and documentation are those
of the authors and should not be interpreted as representing official policies,
either expressed or implied, of the FreeBSD Project.
*/
#pragma once

#include <cstdint>
#include "esp_lcd_panel_io.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

// Elecrow's LovyanGFX fork labels this table ST77961. The unlock bytes and
// Elecrow's product specification identify the installed panel as JD9855.
inline esp_err_t initJd9855(esp_lcd_panel_io_handle_t io)
{
  constexpr std::uint8_t kDelay = 0x80;
  constexpr std::uint8_t commands[] = {
          0xDE, 1, 0x00,
          0xDF, 2, 0x98, 0x55,
          0xB2, 1, 0x1F,
          0xB7, 4, 0x00,0x1D,0x00,0x45,
          0xBB, 6, 0x1B,0x64,0xC4,0x1E,0x3E,0xF5,
          0xBC, 4, 0x03,0x20,0xF3,0xC0,
          0xC0, 2, 0x22,0xA1,
          0xC3, 11, 0x00,0x02,0x2A,0x0B,0x08,0x48,0x08,0x04,0x62,0x30,0x30,
          0xC4, 11, 0x40,0x00,0xAD,0x68,0x43,0x07,0x04,0x16,0x43,0x07,0x04,
          0xC8, 32,
              0x3F,0x36,0x30,0x2D,0x2F,0x31,0x2B,0x2A,
              0x27,0x25,0x1F,0x14,0x10,0x09,0x04,0x00,
              0x3F,0x36,0x30,0x2D,0x2F,0x31,0x2B,0x2A,
              0x27,0x25,0x1F,0x14,0x10,0x09,0x04,0x00,
          0xD3, 2, 0x28, 0x13,
          0xD9, 6, 0x00,0x00,0xFF,0x00,0xF0,0x00,
          0xDE, 1, 0x01,
          0xB7, 8, 0x13,0xE7,0x64,0x39,0x06,0x36,0x19,0x1C,
          0xBE, 1, 0x00,
          0xC1, 3, 0x00,0x4A,0x80,
          0xC2, 4, 0x00,0x16,0xDA,0xE7,
          0xC7, 8, 0x00,0x00,0x00,0x38,0x08,0x08,0x00,0x01,
          0xC8, 6, 0x00,0x00,0x00,0x00,0x15,0x3B,
          0xC9, 5, 0x00,0x16,0x06,0x04,0x0A,
          0xCA, 5, 0x08,0x35,0x16,0x1F,0x1F,
          0xCB, 5, 0x01,0x16,0x07,0x05,0x0B,
          0xCC, 5, 0x09,0x35,0x16,0x1F,0x1F,
          0xCD, 5, 0x01,0x16,0x09,0x0B,0x05,
          0xCE, 5, 0x07,0x15,0x1F,0x16,0x1F,
          0xCF, 5, 0x00,0x16,0x08,0x0A,0x04,
          0xD0, 5, 0x06,0x15,0x1F,0x16,0x1F,
          0xD1, 2, 0x02,0x30,
          0xD2, 5, 0x02,0x03,0x52,0xDF,0xDD,
          0xD3, 3, 0x3B,0x04,0x48,
          0xD5, 7, 0x10,0x10,0x07,0x07,0x0F,0x94,0x26,
          0xD6, 3, 0x00,0x00,0x40,
          0xD7, 3, 0x00,0x00,0x20,
          0xDE, 1, 0x02,
          0xB6, 1, 0x1C,
          0xDE, 1, 0x00,
          0x4D, 1, 0x00,
          0x4E, 1, 0x00,
          0x4F, 1, 0x00,
          0x4C, 1 + kDelay, 0x01, 10,
          0x4C, 1, 0x00,
          0x35, 0,
          0x3A, 1, 0x05,
          0x2A, 4, 0x00,0x00,0x01,0x67,
          0x2B, 4, 0x00,0x00,0x01,0x67,
          0x11, kDelay, 120,
          0x29, 0,
          };
  for (unsigned offset = 0; offset < sizeof(commands);) {
    const auto command = commands[offset++];
    const auto flags = commands[offset++];
    const unsigned count = flags & ~kDelay;
    const esp_err_t result = esp_lcd_panel_io_tx_param(io, command, commands + offset, count);
    if (result != ESP_OK) return result;
    offset += count;
    if (flags & kDelay) vTaskDelay(pdMS_TO_TICKS(commands[offset++]));
  }
  return ESP_OK;
}
